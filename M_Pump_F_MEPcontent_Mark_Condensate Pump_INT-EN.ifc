Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2017-09-11T11:39:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 11 11:39:07 2017 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{CA77D1D8-659C-4F20-A003-CA0500BEEAD0}\ifc * Database version: 5507 * Database creation date: Mon Sep 11 11:39:05 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Sep 11 11:39:06 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 11 11:39:06 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: Condensate Pump, M_Pump_F_MEPcontent_Mark_Condensate Pump_INT-EN:Condensate Pump:1287564
In: V00
Type - Material: Color RGB 060-060-060, Color RGB 193-193-194
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 392 mm; Length: 362 mm; Width: 141 mm
Type - Identity Data - Article Description: Condensate water pump; Article Type: Condensate Pump; Content Supplier URL: www.mepcontent.eu; Copyright: © Trimble Europe BV; Custom: no; Description: Condensate water pump; EMCS Version: 3.0; ETIM Article Class: EC011712; Family Version: 11.06; Manufacturer: Mark; Manufacturer Art. No.: 3100585; Manufacturer URL: http://www.markeire.com/air-heating/gas-fired/gs/; MEPcontent Class: PUMP; Model: Condensate Pump; Product Line: Mark; Revit Version: 2018; Type Name: Condensate Pump; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Drain Fixture Units: 0
Type - Other - Category: Mechanical Equipment; Drain Diameter: 30 mm; Family Name: M_Pump_F_MEPcontent_Mark_Condensate Pump_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Elevation: 0 mm
Dimensions - Area: 0.223068 m2; Volume: 0.0143396 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - System Classification: Sanitary
Other - Family: M_Pump_F_MEPcontent_Mark_Condensate Pump_INT-EN: Condensate Pump; Family and Type: M_Pump_F_MEPcontent_Mark_Condensate Pump_INT-EN: Condensate Pump; Type: M_Pump_F_MEPcontent_Mark_Condensate Pump_INT-EN: Condensate Pump; Type Id: M_Pump_F_MEPcontent_Mark_Condensate Pump_INT-EN: Condensate Pump
Phasing - Phase Created: 4. Plan over 10 jaar
